EPENDS_${PN}_remove = "iptables"
RDEPENDS_packagegroup-core-full-cmdline-extended_remove = "iptables iputils"
RDEPENDS_packagegroup-core-full-cmdline-multiuser_remove = "gzip"
RDEPENDS_packagegroup-core-full-cmdline-utils_remove = "cpio util-linux"
