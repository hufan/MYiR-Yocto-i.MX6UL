DESCRIPTION = "Freescale Image "
LICENSE = "MIT"

IMAGE_INSTALL += " \
    imx-kobs \
    swupdate \
    swupdate-www \
    "

