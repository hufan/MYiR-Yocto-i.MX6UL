# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "ec33247a4c88de79129f4af041227059"
SRC_URI[sha256sum] = "1ca8b0d6289af1f768f193cff337207d98c0d71120d97028b35cb7743e7160cc"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
