# Copyright 2017-2019 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3" 

SRC_URI[md5sum] = "2cb9a95223bee98a5b3d86c89ee36a55"
SRC_URI[sha256sum] = "8d189156d713f12b255f16badd0093aaacd16859aa3191603908de07567485a5"

COMPATIBLE_MACHINE = "imxvpuhantro"
